<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TFT_uvodni_zad.ewp</path>
  </project>
  <batchBuild />
</workspace>
